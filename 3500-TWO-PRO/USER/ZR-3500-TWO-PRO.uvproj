# Keil uVision project ZR-3500-TWO-PRO.uvproj, settings and files
target ZR-3500-TWO-PRO (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ZR-3500-TWO-PRO +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o ..\OBJ\/ZR-3500-TWO-PRO.bin ..\OBJ\/ZR-3500-TWO-PRO.axf
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\HARDWARE\18b20;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\PWM;..\HARDWARE\PUMP;..\HARDWARE\RTC;..\HARDWARE\DMT;..\HARDWARE\PRINTER;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\FATFS\src;..\USB\USB_APP;..\MALLOC;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\HARDWARE\SDIO;..\USB\USB_APP;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\FATFS\exfuns;..\SYSTEM\process;..\HARDWARE\24C64;..\HARDWARE\UDISK;..\HARDWARE\WK;..\HARDWARE\LED;..\HARDWARE\BAT;..\HARDWARE\SSDL
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c TASK.c parameter.c sample.c saveresume.c readme.txt
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: stm32f4xx_rcc.c stm32f4xx_usart.c misc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_dac.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_sdio.c
  group HARDWARE
    ../HARDWARE/18b20/: 18b20.c
    ../HARDWARE/24C64/: 24c64.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/PUMP/: PUMP.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/DMT/: DMT.c
    ../HARDWARE/PRINTER/: print.c
    ../HARDWARE/W25QXX/: w25qxx.c file.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/UDISK/: usb.c
    ../HARDWARE/WK/: wk.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BAT/: bat.c
    ../HARDWARE/SSDL/: SSDL.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/process/: process.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c mycc936.c fattester.c unicode.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_core.c usb_hcd.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbh_usr.c
  group MALLOC
    ../MALLOC/: malloc.c
